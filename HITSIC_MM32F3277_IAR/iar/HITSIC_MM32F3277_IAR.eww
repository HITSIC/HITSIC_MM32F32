<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HITSIC_MM32F3277_IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
