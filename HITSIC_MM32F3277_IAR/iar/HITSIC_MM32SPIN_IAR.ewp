# IAR project HITSIC_MM32SPIN_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; OVERTIME=0; CLOCK=8000000; DEBUG
  ICCARM.CCDiagSuppress: pa082,pe223,pe1665
  ICCARM.CCIncludePath2: ..\board; ..\CMSIS; ..\device; ..\startup; ..\drivers; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: HITSIC_MM32SPIN_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group board
    ../board/: board.c board.h
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group device
    C:/Users/HP/Desktop/MM32F3277/MM32F3277/MM32F3270 Alpha Package/3_Lib_Samples/MM32F3270_Lib_Samples_V0.52/Device/MM32F327x/Include/: mm32_device.h mm32_reg.h mm32_reg_redefine_v1.h reg_adc.h reg_bkp.h reg_can.h reg_common.h reg_comp.h reg_crc.h reg_crs.h reg_dac.h reg_dbg.h reg_dma.h reg_eth.h reg_exti.h reg_flash.h reg_fsmc.h reg_gpio.h reg_i2c.h reg_iwdg.h reg_pwm.h reg_pwr.h reg_rcc.h reg_rtc.h reg_sdio.h reg_spi.h reg_syscfg.h reg_tim.h reg_uart.h reg_usb_otg_fs.h reg_wwdg.h types.h
    ../device/: system_mm32f327x.c
  group drivers
    ../drivers/: dtype.h hal_adc.c hal_adc.h hal_bkp.c hal_bkp.h hal_can.c hal_can.h hal_comp.c hal_comp.h hal_conf.h hal_crc.c hal_crc.h hal_crs.c hal_crs.h hal_dac.c hal_dac.h hal_dbg.c hal_dbg.h hal_device.h hal_dma.c hal_dma.h hal_eth.c hal_eth.h hal_eth_conf.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_iwdg.c hal_iwdg.h hal_misc.c hal_misc.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_redefine.h hal_rtc.c hal_rtc.h hal_sdio.c hal_sdio.h hal_spi.c hal_spi.h hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_uid.c hal_uid.h hal_ver.c hal_ver.h hal_wwdg.c hal_wwdg.h
  group source
    ../source/: isr.cpp main.cpp syscalls.c
  group startup
    ../startup/: startup_mm32f327x_iar.s
